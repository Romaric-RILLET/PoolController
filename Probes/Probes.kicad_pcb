# Repository Romaric-RILLET/PoolController

## KiCad design Probes/Probes.kicad_pcb

Parts:
C1, C11: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C7, C15, C16: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3: 47nF DNP; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C6, C12, C13, C14, C18: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C9, C10: DNP; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8: 300pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C17: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
FB1, FB2: Ferrite_Bead_Small; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
IC1: ADUM1251ARZ; SOIC127P600X175-8N; Manufacturer_Part_Number ADUM1251ARZ; Mouser Part Number 584-ADUM1251ARZ
J1: Conn_Coaxial; BNC_Amphenol_B6252HB-NPP3G-50_Horizontal
J2: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
J3, J4: Conn_01x05_Male; JST_PH_S5B-PH-K_1x05_P2.00mm_Horizontal
J5, J6, J7, J8: Conn_01x01_Female; PinSocket_1x01_P2.00mm_Vertical
PS1: MCP1501T-12E_CHY; SOT-23-6_Handsoldering; Mouser Part Number 579-MCP1501T-12E/CHY
PS2: TBA_2-0521; TBA20521; Mouser Part Number 495-TBA2-0521
R1: 8k2; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 43k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 4M7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R7, R8, R9: DNP; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10, R11, R12, R13: 2700; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14, R15: 560; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: LMC6042IN; DIP-8_W7.62mm_LongPads
U3: ADS1014IDGS; VSSOP-10_3x3mm_P0.5mm

Connections:
+3.3VP: C18.2, IC1.1 (VDD1), J3.2, J4.2, R12.1, R13.1
+5V: C1.1, C2.1, C4.1, C12.1, C14.2, C15.1, FB2.2, IC1.8 (VDD2), PS1.4 (~SHDN), PS1.6 (VDD), PS2.6 (_+VOUT), R10.1, R11.1, R14.1, U1.8 (V+)
+5VP: C17.1, J3.1, J4.1, PS2.1 (_+VIN_(VCC))
-5V: C6.1, C7.1, C13.2, C16.2, PS2.4 (-VOUT), R15.2, U1.4 (V-)
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C10.2, C12.2, C13.1, C14.1, C15.2, C16.1, FB1.2, IC1.5 (GND2), J1.2 (Ext), J2.2, J5.1, PS1.2 (GND_1), PS1.3 (GND_2), PS1.5 (GND_3), PS2.5 (COMMON), R1.2, R14.2, R15.1, U3.5 (AIN1)
GNDPWR: C17.2, C18.1, IC1.4 (GND1), J3.3, J4.3, PS2.2 (-VIN_(GND))
unnamed: C3.1, C5.1, R2.1, R4.2, U1.1 (OUT)
unnamed: C3.2, R1.1, R2.2, U1.2 (IN-)
unnamed: C8.1, PS1.1 (OUT), U1.5 (IN+)
unnamed: C9.2, R4.1, R5.2, U1.6 (IN-)
unnamed: C9.1, C10.1, J6.1, R5.1, U1.7 (OUT), U3.4 (AIN0)
unnamed: C11.1, FB2.1, R7.2, U3.8 (VDD)
unnamed: C11.2, FB1.1, R9.2, U3.3 (GND)
unnamed: IC1.6 (SCL2), J8.1, R6.1, R10.2, U3.10 (SCL)
unnamed: IC1.7 (SDA2), J7.1, R8.1, R11.2, U3.9 (SDA)
unnamed: J1.1 (In), J2.1, R3.2
unnamed: R3.1, U1.3 (IN+)
unnamed: R6.2, R7.1, R8.2, R9.1, U3.1 (ADDR)
SCL: IC1.3 (SCL1), J3.4, J4.4, R12.2
SDA: IC1.2 (SDA1), J3.5, J4.5, R13.2

Notes on the sheet:
PH : gain = 6.25, R2=43K, R1=8K2 ORP : gain = 1.25, R2=30K, R1=120K (https://jansson.us/resistors.html)
Vs=2V5 - Va
Va=Vsonde*( 1 + R2/R1)

Board: 2 copper layers, 79.5 x 39.0 mm, 48 parts (8 on the bottom side), 20 nets.

## KiCad design Controller/Controller.kicad_pcb

Schematic: Controller.sch, Pool Controler

Parts:
B1: 1065
C1: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 0.1uF; CP_Radial_D5.0mm_P2.50mm
C3, C4: 22uF; CP_Radial_D6.3mm_P2.50mm
C5, C6, C7, C8: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9, C10, C11, C12, C13, C14: 4.7uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D6, D7, D8, D9, D10: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
F1: Polyfuse; Fuse_1812_4532Metric_Pad1.30x3.40mm_HandSolder
F2: Fuse_Small; Fuse-PTF75_Stelvio; mouser_pn 710-696101000002; digikey_pn 732-11370-ND
FB1, FB2: Ferrite_Bead_Small; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Probes; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical; mpn B6B-PH-K-S; digikey_pn 455-1708-ND
J2: Display; IDC-Header_2x07_P2.54mm_Latch_Horizontal; mouser_pn 517-N3314-5302RB; digikey_pn MHR14N-ND
J3: ESP32; PinSocket_1x06_P2.54mm_Vertical
J4: EXT_SPI; JST_PH_B7B-PH-K_1x07_P2.00mm_Vertical; mpn B7B-PH-K-S; farnell_pn 9491864
J5: EXT_1; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical; mpn B5B-PH-K-S; digikey_pn 455-1707-ND
J6: Pressure; JST_PH_S3B-PH-SM4-TB_1x03-1MP_P2.00mm_Horizontal; mpn S3B-PH-K-S; digikey_pn 455-1720-ND
J7: Acid Level; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal; mpn S2B-PH-K-S; farnell_pn 9491902
J8: VInput; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; mouser_pn 651-1729128; digikey_pn 277-1247-ND
J9: Temp1; JST_PH_S3B-PH-SM4-TB_1x03-1MP_P2.00mm_Horizontal; mpn S3B-PH-K-S; digikey_pn 455-1720-ND
J10: Chlorine Level; JST_PH_S2B-PH-SM4-TB_1x02-1MP_P2.00mm_Horizontal; mpn S2B-PH-K-S; farnell_pn 9491902
J11: EXT_2; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical; mpn B4B-PH-K-S; farnell_pn 9492437
J12: Temp2; JST_PH_S3B-PH-SM4-TB_1x03-1MP_P2.00mm_Horizontal; mpn S3B-PH-K-S; digikey_pn 455-1720-ND
J13: Eth; PinHeader_2x03_P2.00mm_Vertical
J14: Acid Pump; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; mpn 1729128; digikey_pn 277-1247-ND
J15: Chlorine Pump; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; mpn 1729128; digikey_pn 277-1247-ND
J16: Filtration Pump; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; mpn 1729128; digikey_pn 277-1247-ND
J17: Lighting; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; mpn 1729128; digikey_pn 277-1247-ND
J18: Air; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; mpn 1729128; digikey_pn 277-1247-ND
J19: Flood sensor; JST_PH_S3B-PH-SM4-TB_1x03-1MP_P2.00mm_Horizontal; mpn S3B-PH-K-S; digikey_pn 455-1720-ND
J20: EXT_I2C; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical; mpn B5B-PH-K-S; digikey_pn 455-1707-ND
J21: EXT_UART; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical; mpn B5B-PH-K-S; digikey_pn 455-1707-ND
J22: J1B1211CCD; RJ45_Cetus_J1B1211CCD_Horizontal; Mouser Part Number 950-J1B1211CCD
J23: Relay_Ext; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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; mpn 1729128; digikey_pn 277-1247-ND
J24: air switch; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical; mpn S3B-PH-K-S; digikey_pn 455-1720-ND
J25: EXT_3; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical; mpn B5B-PH-K-S; digikey_pn 455-1707-ND
JP1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical
K1, K2, K3, K4, K5, K6: ALQ305; RELAY_ALQ305; mouser_pn 769-ALQ305; digikey_pn 255-3559-ND
L1, L2: 10uH; L_1206_3216Metric_Pad1.22x1.90mm_HandSolder
R1, R2, R4, R5: dnp; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3, R10, R11, R12, R13, R14: 390; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R7, R8: 4K7; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: Teensy4.1; Teensy41_nousb_noeth; mouser_pn 485-4622
U2: ADS1014IDGS; TSSOP-10_3x3mm_P0.5mm
U3: K7805M-1000R3; PARTREV 2020.01.08-A/5
U4: K7803M-1000R3; PARTREV 2020.01.08-A/5
U5: ULN2003A; DIP-16_W7.62mm_LongPads; mouser_pn 595-ULN2003ANE4; digikey_pn 296-36174-5-ND

Connections:
+3V3: C8.2, FB1.1, J1.2, J2.4, J3.2, J4.2, J5.3, J9.2, J11.2, J12.2, J19.2, J20.2, J21.3, J24.2, J25.2, L2.2, R8.2
+5V: C7.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, J1.1, J2.2, J4.3, J5.2, J6.1, J20.3, J21.2, JP1.2, K1.C1, K2.C1, K3.C1, K4.C1, K5.C1, K6.C1, L1.2, R3.1, R10.1, R11.1, R12.1, R13.1, R14.1, U1.48, U5.9 (COM)
/RX+: J13.6, J22.4
/RX-: J13.5, J22.6
/TX+: J13.1, J22.1
/TX-: J13.2, J22.3
ACID_LEVEL: J7.2, U1.5
CHLORINE_LEVEL: J10.2, U1.4
DISP_RST: J2.13, U1.6
ESP_BOOT: J3.3, U1.25
ESP_EN: J3.4, U1.28
ESP_RX: J3.5, U1.26
ESP_TX: J3.6, U1.27
EXT_CS: J4.5, U1.12
EXT_IO1: J5.4, U1.44
EXT_IO2: J5.5, U1.43
EXT_IO3: J11.3, U1.42
EXT_IO4: J11.4, U1.11
EXT_IO5: J25.5, U1.36
EXT_IO6: J25.4, U1.8
EXT_IO7: J25.3, U1.7
EXT_MISO: J4.7, U1.14
EXT_MOSI: J4.6, U1.13
EXT_RX: J21.4, U1.9
EXT_SCK: J4.4, U1.35
EXT_SCL: J20.4, R2.1, U1.16, U2.10
EXT_SDA: J20.5, R1.1, U1.17, U2.9
EXT_TX: J21.5, U1.10
GND: C3.2, C4.2, C5.2, C6.1, C7.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, FB2.1, J1.3, J2.1, J2.3, J3.1, J4.1, J5.1, J6.3, J7.1, J8.1, J9.3, J10.1, J11.1, J12.3, J19.3, J20.1, J21.1, J24.3, J25.1, R7.2, U1.1, U1.34, U1.47, U2.5, U3.2, U4.2, U5.8 (GND)
LCD_BackLight: J2.5, U1.29
LCD_CS: J2.14, U1.2
LCD_DC: J2.8, U1.30
LCD_MISO: J2.12, U1.3
LCD_MOSI: J2.6, U1.18
LCD_SCLK: J2.10, U1.19
unnamed: B1.1, U1.52
unnamed: B1.2, U1.50
unnamed: C1.1, FB1.2, R4.1, U2.8
unnamed: C1.2, FB2.2, R5.1, U2.3
unnamed: C2.1, J22.2, J22.5
unnamed: C2.2, J13.3, J22.8, J22.9
unnamed: C3.1, C4.1, F1.1, F2.2, U3.1, U4.1
unnamed: C5.1, L1.1, U3.3
unnamed: C6.2, L2.1, U4.3
unnamed: D1.1 (K), K6.C2, U5.16 (O1)
unnamed: D1.2 (A), R3.2
unnamed: D6.1 (K), K5.C2, U5.11 (O6)
unnamed: D6.2 (A), R10.2
unnamed: D7.1 (K), K4.C2, U5.12 (O5)
unnamed: D7.2 (A), R11.2
unnamed: D8.1 (K), K3.C2, U5.13 (O4)
unnamed: D8.2 (A), R12.2
unnamed: D9.1 (K), K2.C2, U5.14 (O3)
unnamed: D9.2 (A), R13.2
unnamed: D10.1 (K), K1.C2, U5.15 (O2)
unnamed: D10.2 (A), R14.2
unnamed: F1.2, F2.1, J8.2
unnamed: J6.2, R6.1
unnamed: J13.4, J22.10
unnamed: J14.1, K1.NO
unnamed: J14.2, K1.COM
unnamed: J15.1, K2.NO
unnamed: J15.2, K2.COM
unnamed: J16.1, K3.NO
unnamed: J16.2, K3.COM
unnamed: J17.1, K4.NO
unnamed: J17.2, K4.COM
unnamed: J18.1, K5.NO
unnamed: J18.2, K5.COM
unnamed: J23.1, K6.NO
unnamed: J23.2, K6.COM
unnamed: JP1.1, U1.49
unnamed: R1.2, R2.2, R4.2, R5.2, U2.1
unnamed: R6.2, R7.1, U2.4
Probe_SCL: J1.4, U1.38
Probe_SDA: J1.5, U1.39
Relay1: U1.24, U5.1 (I1)
Relay2: U1.23, U5.2 (I2)
Relay3: U1.22, U5.3 (I3)
Relay4: U1.21, U5.4 (I4)
Relay5: U1.20, U5.5 (I5)
Relay6: U1.32, U5.6 (I6)
TOUCH_INT: J2.11, U1.45
TOUCH_SCL: J2.9, U1.41
TOUCH_SDA: J2.7, U1.40
Temp: J9.1, J12.1, R8.1, U1.31
air_switch: J24.1, U1.33
flood: J19.1, U1.37

Notes on the sheet:
Ethernet
relays
Temperature
LCD
Pression
don't connect
Power
PH/ORP
Wifi (optional)
Extension

Board: 2 copper layers, 151.1 x 80.0 mm, 77 parts (1 on the bottom side), 88 nets.

## KiCad design Probe/Probe.kicad_pcb

Board: 2 copper layers, 75.4 x 32.0 mm, 52 parts (0 on the bottom side), 32 nets.

Parts:
C1: 220u; CP_Elec_6.3x7.7
C2, C4: opt; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C11, C16: 1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5, C15: 10u; CP_Elec_6.3x7.7
C6, C7, C8, C12, C13, C14, C17, C18: 100n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C9: 1n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C10: 10u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: LED; LED_1206_3216Metric_Pad1.42x1.75mm_HandSolder
IC1: REF3440QDBVRQ1; SOT95P280X145-6N
IC2: LMP7721MAX_NOPB; SOIC127P600X175-8N
IC3: ADM3260ARSZ-RL7; SOP65P780X200-20N
IC4: LMP7716MM_NOPB; SOP65P490X110-8N
IC5: MAX7321AEE+; max7321aee&plus_
J1, J6: Interface; JST_PH_B6B-PH-K_1x06_P2.00mm_Vertical
J2: Probe; BNC_Amphenol_B6252HB-NPP3G-50_Horizontal
J3, J5: Addr; PinHeader_2x04_P2.54mm_Vertical
R1: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 51k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 1M; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R6, R7, R9, R10, R11, R14, R15, R16, R17, R18: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8: 200k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12, R13: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R19: 650; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R20: 1.5k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ADS1114IDGS; TSSOP-10_3x3mm_P0.5mm
U2: LP5907MFX-4.5; SOT-23-5

Connections:
+3V3: C6.1, IC3.4, IC5.16, J1.2, J5.3, J5.7, J6.2, R6.1, R7.1, R18.2, R19.2
+5V: C5.1, C7.1, IC3.9, J1.1, J6.1, R5.2
GND: C1.2, C2.2, C3.2, C4.2, C8.2, C10.2, C11.2, C12.1, C13.2, C14.2, C15.2, C16.2, C17.1, C18.1, IC1.1, IC1.2, IC2.3, IC3.11, IC3.14, IC3.16, IC3.20, IC4.4, J3.7, R10.2, R17.2, R20.2, U1.3, U2.2
GNDPWR: C5.2, C6.2, C7.2, IC3.1, IC3.5, IC3.7, IC3.10, IC5.8, J1.3, J5.1, J5.5, J6.3
unnamed: C4.1, C9.1, IC2.8, R4.1, R8.2, R11.2
unnamed: C9.2, IC2.4, R8.1, R12.2
unnamed: C10.1, IC1.5, IC1.6, R9.1
unnamed: C11.1, IC4.3, R9.2, R10.1
unnamed: C12.2, R12.1, U1.4
unnamed: C13.1, R13.1, U1.5
unnamed: C14.1, C15.1, C16.1, D2.2, IC3.12, IC3.17, R16.1, U2.1, U2.3
unnamed: D1.1, IC5.9
unnamed: D1.2, R19.1
unnamed: D2.1, R20.1
unnamed: IC2.1, R3.1
unnamed: IC3.13, R16.2, R17.1
unnamed: IC4.5, R11.1
unnamed: IC5.1, J5.6, J5.8
unnamed: IC5.3, J5.2, J5.4
unnamed: J2.1, R3.2
unnamed: J3.2, J3.4, J3.6, J3.8, U1.1
unnamed: R2.1, R4.2
PDIS: IC3.8, IC5.12, R5.1
RST: IC5.2, J1.6, J6.6, R18.1
SCL1: IC3.19, J3.5, R14.2, U1.10
SCL2: IC3.2, IC5.14, J1.4, J6.4, R7.2
SDA1: IC3.18, J3.3, R15.2, U1.9
SDA2: IC3.3, IC5.15, J1.5, J6.5, R6.2
VAA: C3.1, C17.2, IC1.3, IC1.4, J3.1, R1.1, R14.1, R15.1, U1.8, U2.5
VDDF: C1.1, C8.1, C18.2, IC2.6, IC4.8, R1.2
VRef: C2.1, IC4.1, IC4.2, J2.2, R2.2, R13.2
guard_ring: IC2.2, IC2.7, IC4.6, IC4.7

## Commit log

2021-06-28 board
2021-07-01 new schematic
2021-07-11 github action
2021-07-11 test github action
2021-07-12 action
2021-07-12 kibot
2021-07-14 Rename config.kibot.yaml to config.kibot.yml
2021-07-14 Rename config.kibot.yml to config.kibot.yaml
2021-07-14 docs directory
2021-07-14 rename Controller-documentation.pdf to Controller-board.pdf
2021-07-16 remove space
2021-07-16 Ethernet on front
2021-07-16 clean
2021-07-16 Archive project
2021-07-18 probe bom
2021-07-18 archive
2021-07-18 export probe
2021-07-18 connect gnd
2021-07-18 bad 3d model
2021-07-18 3d views
2021-09-02 TE_1775485 -> keystone 1065
2021-09-03 make more room for relay
2021-10-11 ethernet diff tuning
2021-10-11 relay ethernet too small
2021-12-04 JST to SMT
2021-12-05 3D S2B-PH-SM4-TB S3B-PH-SM4-TB
2022-02-14 display
2022-02-14 Update exports.yml
    add display
2022-02-14 cache
2022-02-14 rename
2022-02-25 rename probe to old
2022-02-25 probes
2022-02-25 move to probes root directory
2022-03-05 probe
2022-03-19 controller : - K7805M-1000R3 footprint - pressure use ads1014 - display connector position - air switch
2022-03-19 display probe
2022-03-19 JLCPCB gerber
2022-03-20 github action push gerber
2022-04-09 increase Led resistor
2022-09-15 invert ADUM1251 invert J3
2023-02-28 missing gnd missing pull up resistor on DC/DC
2023-03-14 move mounting hole
2023-03-14 horizontal connector
2024-06-02 archive lib
2024-06-06 archive shapes3D
2024-06-06 uneven copper distribution
2024-06-09 move mounting holes

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
